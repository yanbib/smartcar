# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK60D10,UART_USE_DMA
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\emWin\Include;..\MDK;.\mpu6050;.\mpu6050\inc;..\..\..\..\Libraries\utilities\shell;.\nrf
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c
    ./: bluetooth.c timecontrol.c motorcontrol.c AD.c Speed_control.c ledcontrol.c flashcontrol.c QUEUEyan.c
    ./nrf/: nrfcontrolyan.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c can.c cmp.c crc.c dac.c pdb.c vref.c flash.c
  group devices
    ../../../../Libraries/devices/src/: ssd1306.c nrf24l01.c
  group mpu6050
    ./mpu6050/src/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_transplant.c
  group shell
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
